## kernel/common/driver/misc/Kconfig
```kconfig
config TEST_DEVICE
    bool "Test Driver"
    default y
	help
	  Test Driver help
```
